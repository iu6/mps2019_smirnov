# Keil uVision project card.uvprojx, settings and files
target MDR1986VE93Y (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: card +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Source/: main.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:I/O:File 1.2.0, File System:CORE 6.11.0, File System:Drive:Memory Card 6.11.0, CMSIS Driver:SPI:Multi-Slave 1.0.1, Device:Startup 1.5, Drivers:BKP 1.5, Drivers:DMA 1.5, Drivers:LIB 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
